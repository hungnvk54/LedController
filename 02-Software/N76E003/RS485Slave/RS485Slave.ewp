# IAR project RS485Slave.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: N76E003 N76E003
  ICC8051.CCDefines: FOSC_160000=1; N76E003
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Node; NodeStateManager; ..\Common\Command; ..\Common\IRInterface; ..\Common\LedControl; ..\Common\StdPeripheral; ..\Common\Task; ..\Common\TimerUtil; ..\Common\Transport; ..\Common; $PROJ_DIR$
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Nuvoton\lnk51ew_N76E003.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../Common/: inc.h N76E003_it.c N76E003_it.h
    ./: main.c
  group Command
    ../Common/Command/: commands.c commands.h
  group IRInterface
    ../Common/IRInterface/: ir_receiver.c ir_receiver.h ir_transmitter.c ir_transmitter.h
  group LedControl
    ../Common/LedControl/: gpio_util.c gpio_util.h led_controller.c led_controller.h
  group Node
    Node/: nodecontrol.c nodecontrol.h
    NodeStateManager/: nodestatemanager.c nodestatemanager.h
  group StdPeripheral
    ../Common/StdPeripheral/: Common.c Common.h Delay.c Delay.h N76E003_adc.c N76E003_adc.h n76e003_gpio.c n76e003_gpio.h N76E003_pwm.c N76E003_pwm.h N76E003_tim3.c N76E003_tim3.h N76E003_uart0.c N76E003_uart0.h
  group TaskManager
    ../Common/Task/: Task.h TaskManager.c taskmanager.h
  group TimerUtil
    ../Common/TimerUtil/: timer_counter.c timer_counter.h timer_pwm.c timer_pwm.h
  group Transport
    ../Common/Transport/: transport.c transport.h
