<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LedInterMaster.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\LedInterSlave\LedInterSlave.ewp</path>
    </project>
    <batchBuild />
</workspace>
