# IAR project LED_PIR.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003; NDEBUG
  ICCSTM8.CCIncludePath2: ..\Common\STM8S_StdPeriph_Driver\inc; $PROJ_DIR$; ..\Common\Command; Node; ..\Common\TimerUtil; ..\Common\LedControl; ..\Common\IRInterface; ..\Common; ..\Common\Transport; ..\Common\Task; NodeStateManager
  ICCSTM8.IccExtraOptions: --no_path_in_file_macros
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RS485Slave.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S003
  ICCSTM8.CCIncludePath2: Node; NodeStateManager; $PROJ_DIR$; ..\Common; ..\Common\Command; ..\Common\IRInterface; ..\Common\LedControl; ..\Common\STM8S_StdPeriph_Driver\inc; ..\Common\Task; ..\Common\TimerUtil; ..\Common\Transport; ..\Common\PIR
  OBJCOPY.OOCOutputFile: LED_PIR.hex
  ILINK.IlinkOutputFile: LED_PIR.out
  group (top)
    ./: main.c
    ../Common/: stm8s_it.c util.c
  group LedControl
    ../Common/LedControl/: gpio_util.c led_controller.c
  group Node
    Node/: nodecontrol.c
    NodeStateManager/: nodestatemanager.c
  group PIR
    ../Common/PIR/: pir.c
  group StdPeriph_Drivers
    ../Common/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_gpio.c stm8s_itc.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
  group TaskManager
    ../Common/Task/: TaskManager.c
  group TimerUtil
    ../Common/TimerUtil/: timer_counter.c timer_pwm.c
  group Transport
    ../Common/Transport/: transport.c
