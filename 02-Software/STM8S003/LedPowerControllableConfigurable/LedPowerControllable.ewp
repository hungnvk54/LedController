# IAR project LedPowerControllable.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003; NDEBUG; DIMMING
  ICCSTM8.CCIncludePath2: ..\Common\STM8S_StdPeriph_Driver\inc; $PROJ_DIR$; ..\Common\Command; Node; ..\Common\TimerUtil; ..\Common\LedControl; ..\Common\IRInterface; ..\Common; ..\Common\Transport; ..\Common\Task; NodeStateManager; FlashUtil
  ICCSTM8.IccExtraOptions: --no_path_in_file_macros
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S003; DIMMING
  ICCSTM8.CCIncludePath2: NodeStateManager; ..\Common\IRInterface; ..\Common\LedControl; ..\Common\STM8S_StdPeriph_Driver\inc; ..\Common\Task; ..\Common\TimerUtil; ..\Common; FlashUtil
  OBJCOPY.OOCOutputFile: LedDimming.hex
  ILINK.IlinkOutputFile: LedDimming.out
  group (top)
    ./: main.c
    ../Common/: stm8s_it.c util.c
  group FlashUtil
    FlashUtil/: write_flash.c write_flash.h
  group IRInterface
    ../Common/IRInterface/: ir_receiver.c ir_transmitter.c
  group LedControl
    ../Common/LedControl/: gpio_util.c led_controller.c
  group Node
    NodeStateManager/: nodestatemanager.c
  group StdPeriph_Drivers
    ../Common/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_tim1.c stm8s_tim2.c
  group TaskManager
    ../Common/Task/: TaskManager.c
  group TimerUtil
    ../Common/TimerUtil/: timer_counter.c timer_pwm.c
