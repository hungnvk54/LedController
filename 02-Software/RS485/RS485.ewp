# IAR project RS485.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: E:\03-DuAn\LedController\RS485\STM8S_StdPeriph_Driver\inc; E:\03-DuAn\LedController\RS485
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RS485.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_it.c
  group StdPeriph_Drivers
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
